# Keil uVision project stc_demo_project.uvproj, settings and files
target stc_demo (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: stc_demo_project
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC_DEMO
  group Source
    ./: STARTUP.A51 main.c
